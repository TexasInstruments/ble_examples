# IAR project cc26xx_mSBC_library.ewp, settings and files
configuration mSBC (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: AUDIO_RECEIVER; AUDIO_TRANSMITTER; CC26XX; CC26XXWARE; TI_COMPILER_VERSION
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi
  ICCARM.CCIncludePath2: ../../
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_central_audio_receiver_cc2650lp_app.hex
  ILINK.IlinkOutputFile: simple_central_audio_receiver_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $SRC_BLE_CORE$\rom\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mSBCencode (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: xAUDIO_RECEIVER; AUDIO_TRANSMITTER; CC26XX; CC26XXWARE; TI_COMPILER_VERSION
configuration mSBCdecode (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: AUDIO_RECEIVER; xAUDIO_TRANSMITTER; CC26XX; CC26XXWARE; TI_COMPILER_VERSION
  group SBC
    ../../: sbc.c sbc_primitives.c
