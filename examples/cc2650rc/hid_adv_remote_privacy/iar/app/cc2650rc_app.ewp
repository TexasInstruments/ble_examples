# IAR project cc2650rc_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; HEAPMGR_SIZE=0; ICALL_MAX_NUM_TASKS=4; ICALL_MAX_NUM_ENTITIES=7; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XX; CC2650RC; TI_DRIVERS_PDM_INCLUDED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/hid_adv_remote/cc26xx/app; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/audio; $SRC_EX$/profiles/batt/cc26xx; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/hid_dev/cc26xx; $SRC_EX$/profiles/hid_dev_kbd_cc; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/scan_param; $SRC_EX$/profiles/scan_param/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650rc; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/kcb; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $SRC_COMMON$/util/src/cc26xx; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/boards/CC2650RC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hid_adv_remote_privacy_cc2650rc_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs USE_EVENTS=1
  ILINK.IlinkOutputFile: hid_adv_remote_privacy_cc2650rc_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../../src/examples/hid_adv_remote_privacy/cc26xx/app/: hid_adv_remote_privacy.c
    $TI_BLE_SDK_BASE$/src/examples/hid_adv_remote/cc26xx/app/: hid_adv_remote.h
    $TI_BLE_SDK_BASE$/src/components/services/src/kcb/: kcb.c kcb.h
    $TI_BLE_SDK_BASE$/src/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $TI_BLE_SDK_BASE$/src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/Keys
    $TI_BLE_SDK_BASE$/src/components/hal/src/target/cc2650rc/: key_scan.c key_scan.h
  group Drivers/PDM
    $TI_BLE_SDK_BASE$/src/components/hal/src/target/cc2650rc/: PDMCC26XX.c PDMCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.c RF.h
  group ICall
    $TI_BLE_SDK_BASE$/src/components/heapmgr/: heapmgr.h
    $TI_BLE_SDK_BASE$/src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $TI_BLE_SDK_BASE$/src/components/icall/src/inc/: icall.h
    $TI_BLE_SDK_BASE$/src/icall/inc/: icall_addrs.h
  group ICallBLE
    $TI_BLE_SDK_BASE$/src/icall/app/: ble_user_config.c icall_api.c
    $TI_BLE_SDK_BASE$/src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $TI_BLE_SDK_BASE$/src/inc/: gap.h gapgattserver.h gatt.h hci.h
    $TI_BLE_SDK_BASE$/src/profiles/roles/: gapbondmgr.h
    $TI_BLE_SDK_BASE$/src/components/osal/src/inc/: osal_snv.h
  group Middleware/Buzzer
    $TI_RTOS_DRIVERS_BASE$/ti/mw/remotecontrol/: buzzer.c buzzer.h
  group Middleware/ExtFlash
    $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Middleware/Sensors
    $TI_RTOS_DRIVERS_BASE$/ti/mw/sensors/: SensorI2C.c SensorI2C.h SensorMpu9250.c SensorMpu9250.h
  group Profiles
    $TI_BLE_SDK_BASE$/src/profiles/audio/: audio_profile.c audio_profile.h
    $TI_BLE_SDK_BASE$/src/profiles/batt/cc26xx/: battservice.c battservice.h
    $TI_BLE_SDK_BASE$/src/profiles/dev_info/cc26xx/: devinfoservice.c
    $TI_BLE_SDK_BASE$/src/profiles/dev_info/: devinfoservice.h
    $TI_BLE_SDK_BASE$/src/inc/: gatt_profile_uuid.h gatt_uuid.h
    $TI_BLE_SDK_BASE$/src/host/: gatt_uuid.c gattservapp_util.c
    $TI_BLE_SDK_BASE$/src/profiles/hid_dev/cc26xx/: hiddev.c hiddev.h
    $TI_BLE_SDK_BASE$/src/profiles/hid_dev_kbd_cc/: hidkbdccservice.c hidkbdccservice.h
    ../../../../../src/profiles/roles/cc26xx/: peripheral_privacy.c
    $TI_BLE_SDK_BASE$/src/profiles/roles/cc26xx/: peripheral.h
    $TI_BLE_SDK_BASE$/src/profiles/scan_param/cc26xx/: scanparamservice.c
    $TI_BLE_SDK_BASE$/src/profiles/scan_param/: scanparamservice.h
  group Startup
    $TI_BLE_SDK_BASE$/src/target/: board.c
    $TI_BLE_SDK_BASE$/examples/cc2650rc/hid_adv_remote/iar/config/: ccfg_app_ble.c
    $TI_BLE_SDK_BASE$/src/examples/hid_adv_remote/cc26xx/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $TI_BLE_SDK_BASE$/src/common/cc26xx/iar/: cc26xx_app.icf
