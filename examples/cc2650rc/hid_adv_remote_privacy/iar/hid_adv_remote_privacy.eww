<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\cc2650rc_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\stack\cc2650rc_stack.ewp</path>
  </project>
  <batchBuild/>
</workspace>


