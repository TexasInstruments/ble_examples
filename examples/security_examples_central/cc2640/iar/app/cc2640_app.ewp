# IAR project cc2640_app.ewp, settings and files
configuration FlashROM-just_works (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; HEAPMGR_SIZE=5000; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_DISPLAY_INCLUDED; BOARD_DISPLAY_EXCLUDE_UART; GAPCENTRALROLE_NUM_RSSI_LINKS=1; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650DK_7ID; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../../src/security_examples_central/cc26xx/app; $SRC_EX$/inc; $SRC_EX$/icall/inc; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/simple_profile; $SRC_EX$/common/cc26xx; $SRC_COMMON$/applib/src/heap; $SRC_BLE_CORE$/hci; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/host; $SRC_COMMON$/hal/src/target/cc2650tirtos; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/sdata; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/icall/src/inc; $SRC_BLE_CORE$/inc; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: security_examples_central_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: security_examples_central_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM-numeric-comparison (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MAX_PDU_SIZE=70; USE_ICALL; POWER_SAVING; STATIC_PASSCODE; HEAPMGR_SIZE=5000; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_DISPLAY_INCLUDED; BOARD_DISPLAY_EXCLUDE_UART; GAPCENTRALROLE_NUM_RSSI_LINKS=1; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650DK_7ID; CC26XXWARE; CC26XX
configuration FlashROM-passcode (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ICALL; MAX_PDU_SIZE=70; POWER_SAVING; STATIC_PASSCODE; HEAPMGR_SIZE=5000; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_DISPLAY_INCLUDED; BOARD_DISPLAY_EXCLUDE_UART; GAPCENTRALROLE_NUM_RSSI_LINKS=1; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650DK_7ID; CC26XXWARE; CC26XX
configuration FlashROM-OOB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; MAX_PDU_SIZE=70; HEAPMGR_SIZE=5000; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_DISPLAY_INCLUDED; BOARD_DISPLAY_EXCLUDE_UART; GAPCENTRALROLE_NUM_RSSI_LINKS=1; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650DK_7ID; CC26XXWARE; CC26XX
  group Application
    $SRC_EX$/common/cc26xx/: board_display.c board_display.h board_key.c board_key.h util.c util.h
    ../../../../../src/security_examples_central/cc26xx/app/: just_works.c numeric_comparison.c OOB.c passcode.c security_examples_central.h
  group Drivers/LCD
    ../../../../../../ti/tirtos_simplelink_2_13_00_06/packages/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    ../../../../../../ti/tirtos_simplelink_2_13_00_06/packages/ti/drivers/: PIN.h
    ../../../../../../ti/tirtos_simplelink_2_13_00_06/packages/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    ../../../../../../ti/tirtos_simplelink_2_13_00_06/packages/ti/drivers/: SPI.c SPI.h
    ../../../../../../ti/tirtos_simplelink_2_13_00_06/packages/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    ../../../../../../ti/tirtos_simplelink_2_13_00_06/packages/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $SRC_COMMON$/applib/src/heap/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $SRC_COMMON$/icall/src/inc/: icall.h
    $SRC_EX$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_EX$/icall/app/: ble_user_config.c icall_api.c
    ../config/: ble_user_config.h
    $SRC_EX$/icall/inc/: icall_apimsg.h
  group Include
    $SRC_BLE_CORE$/inc/: gap.h gatt.h hci.h
    $SRC_EX$/profiles/roles/: gapbondmgr.h
    $SRC_EX$/inc/: gapgattserver.h
    $SRC_COMMON$/osal/src/inc/: osal_snv.h
  group PROFILES
    $SRC_EX$/profiles/roles/cc26xx/: central.c central.h
  group Startup
    $SRC_COMMON$/hal/src/target/cc2650tirtos/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../src/security_examples_central/cc26xx/app/: main.c
  group TOOLS
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $SRC_EX$/common/cc26xx/iar/: cc26xx_app.icf
