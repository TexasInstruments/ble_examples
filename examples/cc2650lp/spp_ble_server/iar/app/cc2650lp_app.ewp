# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_ICALL; xPOWER_SAVING; SDI_USE_UART; MAX_PDU_SIZE=162; HEAPMGR_SIZE=0; ICALL_MAX_NUM_TASKS=4; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650_LAUNCHXL; CC26XX; Display_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; ..\..\..\..\..\src\profiles\serial_port\; ..\..\..\..\..\src\profiles\serial_port\cc26xx; ..\..\..\..\..\src\examples\spp_ble_server\cc26xx\app\; $SRC_EX$/target; $SRC_COMMON$/heapmgr; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; ..\..\..\..\..\src\components\sdi; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spp_ble_server_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: spp_ble_server_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../../src/common/cc2650lp/: board_key.c board_key.h
    ../../../../../src/examples/spp_ble_server/cc26xx/app/: spp_ble_server.c spp_ble_server.h
    $TI_BLE_SDK$/src/common/cc26xx/: util.c util.h
  group ICall
    $TI_BLE_SDK$/src/components/heapmgr/: heapmgr.h
    $TI_BLE_SDK$/src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $TI_BLE_SDK$/src/components/icall/src/inc/: icall.h
    $TI_BLE_SDK$/src/icall/inc/: icall_addrs.h
  group ICallBLE
    $TI_BLE_SDK$/src/icall/app/: ble_user_config.c icall_api.c
    $TI_BLE_SDK$/src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $TI_BLE_SDK$/src/inc/: gap.h gapgattserver.h gatt.h hci.h
    $TI_BLE_SDK$/src/profiles/roles/: gapbondmgr.h
    $TI_BLE_SDK$/src/components/osal/src/inc/: osal_snv.h
  group Profiles
    $TI_BLE_SDK$/src/profiles/dev_info/cc26xx/: devinfoservice.c
    $TI_BLE_SDK$/src/profiles/dev_info/: devinfoservice.h
    $TI_BLE_SDK$/src/inc/: gatt_profile_uuid.h gatt_uuid.h
    $TI_BLE_SDK$/src/host/: gatt_uuid.c gattservapp_util.c
    $TI_BLE_SDK$/src/profiles/roles/cc26xx/: peripheral.c peripheral.h
    ../../../../../src/profiles/serial_port/CC26xx/: serial_port_service.c
    ../../../../../src/profiles/serial_port/: serial_port_service.h
  group SDI
    ../../../../../src/components/sdi/: sdi_rxbuf.c sdi_task.c sdi_tl.c sdi_tl_uart.c
    ../../../../../src/components/sdi/inc/: sdi_task.h
  group Startup
    $TI_BLE_SDK$/src/components/hal/src/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../src/examples/spp_ble_server/cc26xx/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $TI_BLE_SDK$/src/common/cc26xx/iar/: cc26xx_app.icf
