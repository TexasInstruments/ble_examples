# IAR project beacon_rfdriver.ewp, settings and files
configuration LaunchPad (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC26XXWARE; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; POWER_SAVING; ADV_NC_OPTIMIZED; EVERY_OTHER; CC2650_LAUNCHXL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f config/configPkg/compiler.opt.defs
  ICCARM.CCIncludePath2: ..\..\..\..\src\examples\beacon_rfdriver; $SRC_BLE_CORE$\target\; $SRC_BLE_CORE$\target\cc2650lp; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: beacon_rfdriver.srec
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: led_blinker_tirtos.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1
  ILINK.IlinkIcfFile: $CC26XXWARE$\linker_files\cc26x0f128.icf
  ILINK.IlinkExtraOptions: -f config/configPkg/linker.cmd
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../src/examples/beacon_rfdriver/: main_tirtos.c smartrf_settings.c smartrf_settings.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.c RF.h
  group Startup
    $SRC_BLE_CORE$/target/: board.c
    config/: ccfg.c
  group Tools
    config/: rom.cfg
