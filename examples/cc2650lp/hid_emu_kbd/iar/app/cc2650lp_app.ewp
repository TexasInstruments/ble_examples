# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; HEAPMGR_SIZE=0; ICALL_MAX_NUM_TASKS=4; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650_LAUNCHXL; CC26XX; Display_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; ../../../../../src/common/cc2650lp; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/batt/cc26xx; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/hid_dev/cc26xx; $SRC_EX$/profiles/hid_dev_kbd; $SRC_EX$/profiles/hid_dev_kbd/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/scan_param; $SRC_EX$/profiles/scan_param/cc26xx; $SRC_EX$/target; $SRC_COMMON$/heapmgr; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hid_emu_kbd_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: hid_emu_kbd_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../../src/common/cc2650lp/: board_key.c board_key.h
    ../../../../../src/examples/hid_emu_kbd/cc26xx/app/: hidemukbdlp.c hidemukbdlp.h
    $SRC_BLE_CORE$/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $SRC_BLE_CORE$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.c RF.h
  group ICall
    $SRC_COMMON$/heapmgr/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $SRC_COMMON$/icall/src/inc/: icall.h
    $SRC_BLE_CORE$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_CORE$/icall/app/: ble_user_config.c icall_api.c
    $SRC_BLE_CORE$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_CORE$/inc/: gap.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_CORE$/profiles/roles/: gapbondmgr.h
    $SRC_COMMON$/osal/src/inc/: osal_snv.h
  group Profiles
    $SRC_BLE_CORE$/profiles/batt/cc26xx/: battservice.c battservice.h
    $SRC_BLE_CORE$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_BLE_CORE$/profiles/dev_info/: devinfoservice.h
    $SRC_BLE_CORE$/inc/: gatt_profile_uuid.h gatt_uuid.h
    $SRC_BLE_CORE$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_CORE$/profiles/hid_dev/cc26xx/: hiddev.c hiddev.h
    $SRC_BLE_CORE$/profiles/hid_dev_kbd/cc26xx/: hidkbdservice.c
    $SRC_BLE_CORE$/profiles/hid_dev_kbd/: hidkbdservice.h
    $SRC_BLE_CORE$/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $SRC_BLE_CORE$/profiles/scan_param/cc26xx/: scanparamservice.c
    $SRC_BLE_CORE$/profiles/scan_param/: scanparamservice.h
  group Startup
    $SRC_COMMON$/hal/src/target/: board.c
    ../config/: ccfg_app_ble.c
    $SRC_BLE_CORE$/examples/hid_emu_kbd/cc26xx/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $SRC_BLE_CORE$/common/cc26xx/iar/: cc26xx_app.icf
