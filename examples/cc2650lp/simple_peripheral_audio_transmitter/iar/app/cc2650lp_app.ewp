# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_ICALL; HEAPMGR_METRICS; AUDIO_TRANSMITTER; POWER_SAVING; HEAPMGR_SIZE=0; xDisplay_DISABLE_ALL; xBOARD_DISPLAY_EXCLUDE_UART; BOARD_DISPLAY_EXCLUDE_LCD; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650_LAUNCHXL; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: ../../../../../src/util/audio_codec; ../../../../util/mSBClibrary/include; ../../../../../src/boards/CC2650_LAUNCHXL; $SRC_EX$/examples/simple_peripheral/cc26xx/app; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/audio; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/simple_profile; $SRC_EX$/profiles/simple_profile/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_audio_transmitter_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_peripheral_audio_transmitter_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $TI_BLE_SDK_BASE$/src/common/cc26xx/: board_key.c board_key.h util.c util.h
    $TI_BLE_SDK_BASE$/src/examples/simple_peripheral/cc26xx/app/: simple_peripheral.h
    ../../../../../src/examples/simple_peripheral_audio_transmitter/cc26xx/app/: simple_peripheral_audio_transmitter.c
  group Drivers/Audio Codec
    ../../../../../src/util/audio_codec/: audiocodec.c audiocodec.h I2SCC26XX.c I2SCC26XX.h ti3254.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pdm/: Codec1.c Codec1.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayDogm1286.c DisplayDogm1286.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    $TI_BLE_SDK_BASE$/src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SBC
    ../../../../util/mSBClibrary/bin/: cc2650_mSBCencode_library.a
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    $TI_BLE_SDK_BASE$/src/components/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $TI_BLE_SDK_BASE$/src/components/heapmgr/: heapmgr.h
    $TI_BLE_SDK_BASE$/src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $TI_BLE_SDK_BASE$/src/components/icall/src/inc/: icall.h
    $TI_BLE_SDK_BASE$/src/icall/inc/: icall_addrs.h
  group ICallBLE
    $TI_BLE_SDK_BASE$/src/icall/app/: ble_user_config.c icall_api.c
    $TI_BLE_SDK_BASE$/src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $TI_BLE_SDK_BASE$/src/inc/: gap.h gapgattserver.h gatt.h hci.h
    $TI_BLE_SDK_BASE$/src/profiles/roles/: gapbondmgr.h
    $TI_BLE_SDK_BASE$/src/components/osal/src/inc/: osal_snv.h
  group Profiles
    $TI_BLE_SDK_BASE$/src/profiles/audio/: audio_profile.c
    $TI_BLE_SDK_BASE$/src/profiles/dev_info/cc26xx/: devinfoservice.c
    $TI_BLE_SDK_BASE$/src/profiles/dev_info/: devinfoservice.h
    $TI_BLE_SDK_BASE$/src/inc/: gatt_profile_uuid.h gatt_uuid.h
    $TI_BLE_SDK_BASE$/src/host/: gatt_uuid.c gattservapp_util.c
    $TI_BLE_SDK_BASE$/src/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $TI_BLE_SDK_BASE$/src/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $TI_BLE_SDK_BASE$/src/profiles/simple_profile/: simple_gatt_profile.h
  group Startup
    ../../../../../src/boards/CC2650_LAUNCHXL/: CC2650_LAUNCHXL.c
    $TI_BLE_SDK_BASE$/examples/cc2650em/simple_peripheral/iar/config/: ccfg_app_ble.c
    $TI_BLE_SDK_BASE$/src/examples/simple_peripheral/cc26xx/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $TI_BLE_SDK_BASE$/src/common/cc26xx/iar/: cc26xx_app.icf
