<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\cc2640r2lp_app.ewp</path>
  </project>
  <batchBuild/>
</workspace>


