# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashOnly_MultiMode (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; FEATURE_ADVERTISER; FEATURE_BROADCASTER; FEATURE_OBSERVER; FEATURE_SCANNER; FEATURE_STATIC_ADDR; HEAPMGR_SIZE=0; POWER_SAVING; RF_MULTIMODE; TBM_ACTIVE_ITEMS_ONLY; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $XDCROOT$\packages; $SRC_BLE_DIR$\boards; $SRC_BLE_DIR$\boards\CC2640R2_LAUNCHXL; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $EXAMPLE_BLE_ROOT$\src\app\board_cc2640r2lp; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: ble_uble_bcast_scan_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app.icf
  ILINK.IlinkExtraOptions: -f ..\config\configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\iar\m3\grlib.a; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_multiMode_cc26x0r2.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/: board_key.c board_key.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/menu/: two_btn_menu.c two_btn_menu.h
    ../../../src/app/: uble_bcast_scan.c uble_bcast_scan.h uble_bcast_scan_menu.c
  group HAL/Common
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/common/: hal_assert.c
  group HAL/Include
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/inc/: hal_assert.h
  group Stack
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/microstack/: port.c uble.c ugap.c ull.c urfi.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/inc/: port.h uble.h ugap.h ull.h urfi.h
  group Startup
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/target/: board.c
    ../../../src/: ccfg_app_ble.c
    ../../../src/app/: main.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/boards/: urfc.c urfc.h
  group Tools
    ../../: app_ble.cfg
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/iar/: cc26xx_app.icf
  group Util
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/: util.c util.h
