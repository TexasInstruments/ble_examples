# IAR project cc2640r2lp_stack.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; EXT_HAL_ASSERT; FLASH_ROM_BUILD; GATT_NO_CLIENT; ICALL_EVENTS; ICALL_JT; ICALL_LITE; OSAL_CBTIMER_NUM_TASKS=1; OSAL_SNV=1; POWER_SAVING; USE_CORE_SDK; USE_ICALL
  ICCARM.IExtraOptions: --aeabi; -f $SRC_BLE_DIR$/config/build_components.opt; -f $SRC_BLE_DIR$/config/factory_config.opt; -f build_config.opt; --diag_suppress=Pa050; -Dxdc_target_types__=iar/targets/arm/std.h; --make_all_definitions_weak
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$/controller/cc26xx_r2/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/rom; $SRC_BLE_DIR$/common/cc26xx; $SRC_BLE_DIR$/common/cc26xx/npi/stack; $SRC_COMMON_DIR$/hal/src/target/_common; ..\..\..\src/stack; $SRC_BLE_DIR$/icall/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/profiles/roles; $SRC_COMMON_DIR$/hal/src/inc; $SRC_COMMON_DIR$/hal/src/target/_common/cc26xx; $SRC_COMMON_DIR$/hal/src/target/_common; $SRC_COMMON_DIR$/hal/src/target; $SRC_COMMON_DIR$/icall/src/inc; $SRC_COMMON_DIR$/npi/src; $SRC_COMMON_DIR$/osal/src/inc; $SRC_COMMON_DIR$/services/src/nv; $SRC_COMMON_DIR$/services/src/nv/cc26xx; $SRC_COMMON_DIR$/services/src/saddr; $TI_RTOS_KERNEL$/packages; $CC26XXWARE$; $CC26XXWARE$/rf_patches; $CC26XXWARE$\inc; $TI_RTOS_DRIVERS_BASE$; $XDCROOT$/packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spp_ble_server_cc2640r2lp_stack.hex
  prebuild: $TOOLS_BLE_DIR$/lib_search/lib_search.exe build_config.opt $SRC_BLE_DIR$/blelib  ../config/lib_linker.cmd cc2640 $TOOLS_BLE_DIR$/lib_search/lib_search.xml $SRC_BLE_DIR$/symbols
  postbuild: "$TOOLS_BLE_DIR$/frontier/frontier.exe" iar "$CONFIG_NAME$/List/spp_ble_server_cc2640r2lp_stack.map" "../config/iar_boundary.bdef" "../config/iar_boundary.xcl"
  ILINK.IlinkOutputFile: spp_ble_server_cc2640r2lp_stack.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=2; CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$/common/cc26xx/iar/cc26xx_stack.icf
  ILINK.IlinkExtraOptions: -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: startup_entry
configuration FlashROM_Library (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; EXT_HAL_ASSERT; FLASH_ROM_BUILD; GATT_NO_CLIENT; ICALL_EVENTS; ICALL_JT; ICALL_LITE; OSAL_CBTIMER_NUM_TASKS=1; OSAL_SNV=1; POWER_SAVING; STACK_LIBRARY; USE_CORE_SDK; USE_ICALL
  group HAL/Common
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/common/: hal_assert.c
  group HAL/Include
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/target/_common/: hal_mcu.h
  group HAL/Target/CC2650/Config
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group Host
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/host/: gatt_uuid.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/inc/: gatt_uuid.h
  group ICallBLE
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/inc/: ble_dispatch.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/stack/: ble_dispatch_JT.c ble_dispatch_lite.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/src/: icall_lite_translation.c
  group NPI
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/npi/stack/: npi.c
  group OSAL
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group Profiles
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/profiles/roles/: gap.c gapbondmgr.c gapbondmgr.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/inc/: gapgattserver.h gattservapp.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/host/: gattservapp_util.c sm_ecc.c
  group ROM
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/rom/r2/: common_rom_init.c rom_flash_jt.h rom_init.c
  group Startup
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/stack/: ble_user_config.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/: icall_startup.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/examples/rtos/CC2640R2_LAUNCHXL/blestack/simple_peripheral/src/stack/: osal_icall_ble.c
  group Tools
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/config/: build_components.opt
    ./: build_config.opt
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/iar/: cc26xx_stack.icf
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/: onboard.c onboard.h
