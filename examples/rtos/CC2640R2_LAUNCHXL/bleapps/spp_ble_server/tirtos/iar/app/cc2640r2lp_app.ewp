# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=0; BOARD_DISPLAY_USE_UART_ANSI=0; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=4; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; xPOWER_SAVING; SDI_USE_UART; RF_SINGLEMODE; STACK_LIBRARY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $EXAMPLE_BLE_ROOT$\..\..\..\..\..\source\ti\blestack\profiles\serial_port; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $EXAMPLE_BLE_ROOT$\..\..\..\..\..\source\ti\blestack\sdi\src; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0 -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: spp_ble_server_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_StackLibrary_RCOSC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; USE_ICALL; USE_RCOSC; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\rcosc; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  group Application
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/: board_key.c board_key.h util.c util.h
    ../../../src/app/: spp_ble_server.c spp_ble_server.h
  group Drivers
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/target/_common/: hal_flash_wrapper.c
  group Drivers/ECC
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/src/inc/: icall.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/inc/: icall_addrs.h
  group ICallBLE
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/app/: ble_user_config.c icall_api_lite.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/inc/: gap.h gapgattserver.h gatt.h hci.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/profiles/roles/: gapbondmgr.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/osal/src/inc/: osal_snv.h
  group Profiles
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/profiles/dev_info/cc26xx/: devinfoservice.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/profiles/dev_info/: devinfoservice.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/inc/: gatt_profile_uuid.h gatt_uuid.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/host/: gatt_uuid.c gattservapp_util.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/profiles/roles/cc26xx/: peripheral.c peripheral.h
    ../../../../../../../../source/ti/blestack/profiles/serial_port/: serial_port_service.c serial_port_service.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/profiles/simple_profile/: simple_gatt_profile.h
  group SDI
    ../../../../../../../../source/ti/blestack/sdi/src/: sdi_rxbuf.c sdi_task.c sdi_tl.c sdi_tl_uart.c
    ../../../../../../../../source/ti/blestack/sdi/src/inc/: sdi_task.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/target/: board.c
    ../../../src/: ccfg_app_ble.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    ../../../src/app/: main.c
  group Tools
    ../../: app_ble.cfg
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/blestack/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_and_stack.icf
