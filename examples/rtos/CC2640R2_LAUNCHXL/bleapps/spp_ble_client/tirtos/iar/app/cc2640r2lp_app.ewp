# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=0; BOARD_DISPLAY_USE_UART_ANSI=0; CC2640R2_LAUNCHXL; SDI_USE_UART; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=4; ICALL_STACK0_ADDR; xPOWER_SAVING; STACK_LIBRARY; USE_ICALL; HEAPMGR_METRICS; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$/config/build_components.opt; -f $SRC_BLE_DIR$/config/factory_config.opt; -f $EXAMPLE_BLE_ROOT$/tirtos/build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$/controller/cc26xx_r2/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/common/cc26xx; ..\..\..\src/app; $SRC_BLE_DIR$/icall/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/profiles/roles; $SRC_BLE_DIR$/profiles/roles/cc26xx; $EXAMPLE_ROOT$\..\..\..\..\..\source\ti\blestack\profiles\serial_port; $EXAMPLE_ROOT$\..\..\..\..\..\source\ti\blestack\profiles\serial_port\cc26xx; $SRC_BLE_DIR$/target; $SRC_BLE_DIR$/hal/src/inc; $SRC_BLE_DIR$/hal/src/target/_common; $SRC_BLE_DIR$/hal/src/target/_common/cc26xx; $SRC_BLE_DIR$/hal/src/target/cc2650/rom; $SRC_BLE_DIR$/heapmgr; $SRC_BLE_DIR$/icall/src/inc; $SRC_BLE_DIR$/osal/src/inc; $SRC_BLE_DIR$/services/src/saddr; $SRC_BLE_DIR$/services/src/sdata; $EXAMPLE_ROOT$\..\..\..\..\..\source\ti\blestack\sdi\src; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spp_ble_client_cc2640r2lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0
  ILINK.IlinkOutputFile: spp_ble_client_cc2640r2lp_app.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$/common/cc26xx/iar/cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl; -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_SL_CacheAsRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=0; BOARD_DISPLAY_USE_UART_ANSI=0; CC2640R2_LAUNCHXL; SDI_USE_UART; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=4; ICALL_STACK0_ADDR; RF_SINGLEMODE; xPOWER_SAVING; STACK_LIBRARY; USE_ICALL; HEAPMGR_METRICS; CACHE_AS_RAM; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  group Application
    $SRC_BLE_DIR$/source/ti/blestack/common/cc26xx/: board_key.c board_key.h util.c util.h
    $EXAMPLE_ROOT$/src/app/: spp_ble_client.c spp_ble_client.h
  group Drivers/ECC
    $SRC_BLE_DIR$/source/ti/blestack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SRC_BLE_DIR$/source/ti/blestack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_BLE_DIR$/source/ti/blestack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_BLE_DIR$/source/ti/blestack/icall/src/inc/: icall.h
    $SRC_BLE_DIR$/source/ti/blestack/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/source/ti/blestack/icall/app/: ble_user_config.c icall_api_lite.c
    $SRC_BLE_DIR$/source/ti/blestack/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_DIR$/source/ti/blestack/inc/: gap.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_DIR$/source/ti/blestack/profiles/roles/: gapbondmgr.h
    $SRC_BLE_DIR$/source/ti/blestack/osal/src/inc/: osal_snv.h
  group Profiles
    $SRC_BLE_DIR$/source/ti/blestack/profiles/roles/cc26xx/: central.c central.h
    ../../../../../../../../source/ti/blestack/profiles/serial_port/: serial_port_service.h
  group SDI
    ../../../../../../../../source/ti/blestack/sdi/src/: sdi_rxbuf.c sdi_task.c sdi_tl.c sdi_tl_uart.c
    ../../../../../../../../source/ti/blestack/sdi/src/inc/: sdi_task.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    $SRC_BLE_DIR$/source/ti/blestack/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ./: app_ble.cfg
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_app_and_stack.icf
    ../config/: iar_boundary.bdef iar_boundary.xcl
