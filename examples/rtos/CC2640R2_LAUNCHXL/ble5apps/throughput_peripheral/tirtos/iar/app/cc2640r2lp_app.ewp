# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CACHE_AS_RAM; MAX_PDU_SIZE=251; MAX_NUM_PDU=6; BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=1; RF_SINGLEMODE; ICALL_STACK0_ADDR; POWER_SAVING; STACK_LIBRARY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$/config/build_components.opt; -f $SRC_BLE_DIR$/config/factory_config.opt; -f $EXAMPLE_BLE_ROOT$/tirtos/build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$/controller/cc26xx_r2/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/common/cc26xx; $SRC_LOCAL_DIR$/profiles/throughput; $EXAMPLE_BLE_ROOT$/src/app; $SRC_BLE_DIR$/icall/inc; $SRC_BLE_DIR$/inc; $SRC_BLE_DIR$/profiles/dev_info; $SRC_BLE_DIR$/profiles/roles; $SRC_BLE_DIR$/profiles/roles/cc26xx; $SRC_BLE_DIR$/target; $SRC_BLE_DIR$/hal/src/inc; $SRC_BLE_DIR$/hal/src/target/_common; $SRC_BLE_DIR$/hal/src/target/_common/cc26xx; $SRC_BLE_DIR$/hal/src/target/cc2650/rom; $SRC_BLE_DIR$/heapmgr; $SRC_BLE_DIR$/icall/src/inc; $SRC_BLE_DIR$/osal/src/inc; $SRC_BLE_DIR$/services/src/saddr; $SRC_BLE_DIR$/services/src/sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $EXAMPLE_BLE_ROOT$\..\app\source; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0 -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: ble5_throughput_peripheral_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2; CACHE_AS_RAM=1
  ILINK.IlinkIcfFile: $SRC_LOCAL_DIR$/common/cc26xx/iar/cc26xx_app_and_stack_throughput.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl; -f ../config/lib_linker.cmd; --diag_suppress=Lt009
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $SRC_BLE_DIR$/common/cc26xx/: board_key.c board_key.h util.c util.h
    $EXAMPLE_BLE_ROOT$/src/app/: throughput_peripheral.c throughput_peripheral.h throughput_peripheral_menu.c throughput_peripheral_menu.h
    $SRC_BLE_DIR$/common/cc26xx/menu/: two_btn_menu.c two_btn_menu.h
  group Drivers
    $SRC_BLE_DIR$/hal/src/target/_common/: hal_flash_wrapper.c
  group Drivers/ECC
    $SRC_BLE_DIR$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SRC_BLE_DIR$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_BLE_DIR$/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_BLE_DIR$/icall/src/inc/: icall.h
    $SRC_BLE_DIR$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/icall/app/: ble_user_config.c icall_api_lite.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    $SRC_BLE_DIR$/inc/: gap.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_DIR$/profiles/roles/: gapbondmgr.h
    $SRC_BLE_DIR$/osal/src/inc/: osal_snv.h
  group Profiles
    $SRC_BLE_DIR$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_BLE_DIR$/profiles/dev_info/: devinfoservice.h
    $SRC_BLE_DIR$/inc/: gatt_profile_uuid.h gatt_uuid.h
    $SRC_BLE_DIR$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_DIR$/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $SRC_LOCAL_DIR$/profiles/throughput/: throughput_service.c throughput_service.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    $SRC_BLE_DIR$/boards/CC2640R2_LAUNCHXL/: CC2640R2_LAUNCHXL.c CC2640R2_LAUNCHXL.h
    ../config/: ccfg_app_ble.c
    $SRC_BLE_DIR$/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    $EXAMPLE_BLE_ROOT$/src/app/: main.c
  group Tools
    ./: app_ble.cfg
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_and_stack.icf cc26xx_app_oad.icf
    ../config/: iar_boundary.bdef iar_boundary.xcl
