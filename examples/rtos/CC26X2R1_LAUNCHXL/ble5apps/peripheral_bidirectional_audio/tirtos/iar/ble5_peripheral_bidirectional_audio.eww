<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\cc26x2r1lp_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\stack\cc26x2r1lp_stack.ewp</path>
  </project>
  <batchBuild/>
</workspace>

