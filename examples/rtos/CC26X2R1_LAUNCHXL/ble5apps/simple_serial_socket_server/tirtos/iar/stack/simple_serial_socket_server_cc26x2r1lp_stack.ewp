# IAR project simple_serial_socket_server_cc26x2r1lp_stack.ewp, settings and files
configuration FlashROM_Library (ARM, debug)
  General.OGChipSelectEditMenu: CC1352R1F3   TexasInstruments CC1352R1F3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC26X2
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; --aeabi; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; --diag_suppress=Pa050; -Dxdc_target_types__=iar\targets\arm\std.h; --make_all_definitions_weak
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\npi\stack; $SRC_BLE_DIR$\hal\src\target\_common; $EXAMPLE_BLE_ROOT$\src\stack; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SRC_BLE_DIR$\services\src\saddr; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\rf_patches; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $XDCROOT$\packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: $TOOLS_BLE_DIR$\lib_search\lib_search.exe --opt $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt --lib-dir $SRC_BLE_DIR$\blelib\cc13x2r1 --cmd ..\config\lib_linker.cmd --xml $TOOLS_BLE_DIR$\lib_search\lib_search.xml --sym-dir $SRC_BLE_DIR$\symbols\cc13x2r1
  ILINK.IlinkOutputFile: ble5_simple_peripheral_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=2; CC2650=2
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/Common
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/common/: hal_assert.c
  group HAL/Include
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: hal_mcu.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/cc26xx/: mb.h rf_hal.h
  group HAL/Target/CC2650/Config
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group Host
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/host/: gap.c gapbondmgr.c gatt_uuid.c gattservapp_util.c sm_ecc.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/inc/: gapbondmgr.h gapgattserver.h gatt_uuid.h gattservapp.h
  group ICallBLE
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/inc/: ble_dispatch.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/stack/: ble_dispatch_JT.c ble_dispatch_lite.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/src/: icall_lite_translation.c
  group NPI
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/npi/stack/: npi.c
  group OSAL
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_list.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_list.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group ROM
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/rom/agama_r1/: common_rom_init.c rom_flash_jt.h rom_init.c
  group Startup
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/stack/: ble_user_config.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/: icall_startup.c
    ../../../src/stack/: osal_icall_ble.c
  group Tools
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/config/: build_components.opt
    ../../: build_config.opt
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/: onboard.c onboard.h
  group Tools/defines
    defines/: simple_serial_socket_server_cc13x2r1lp_stack_FlashROM_Library.opt
