# IAR project simple_serial_socket_server_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ./: simple_serial_socket_server_app.ipcf simple_serial_socket_server_app.cfg
