<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\simple_serial_socket_client_cc26x2r1lp_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\stack\simple_serial_socket_client_cc26x2r1lp_stack.ewp</path>
  </project>
  <batchBuild/>
</workspace>


