# IAR project cc26x2r1lp_app.ewp, settings and files
configuration FlashROM_Release (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC26X2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $EXAMPLE_BLE_ROOT$\..\..\..\..\..\source\ti\ble5stack\profiles\serial_port; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\npi\src; $EXAMPLE_BLE_ROOT$\..\..\..\..\..\source\ti\ble5stack\sdi\src; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\ble_release.cfg
  ILINK.IlinkOutputFile: ble5_simple_peripheral_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2642=1; PAGE_ALIGN=1; FLASH_ROM_BUILD=1
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack_agama.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x2.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x2.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_multiMode_cc26x2.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm4f
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_Debug (ARM, debug)
  as the first configuration, except:
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\ble_debug.cfg
  group Application
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/: board_key.c board_key.h util.c util.h
    ../../../src/app/: spp_ble_server.c spp_ble_server.h
  group Drivers/ECC
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/src/inc/: icall.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/inc/: icall_addrs.h
  group ICallBLE
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/app/: ble_user_config.c icall_api_lite.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/inc/: gap.h gapbondmgr.h gapgattserver.h gatt.h hci.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/osal/src/inc/: osal_snv.h
  group Profiles
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/profiles/dev_info/cc26xx/: devinfoservice.c
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/profiles/dev_info/: devinfoservice.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/inc/: gatt_profile_uuid.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/host/: gatt_uuid.c gatt_uuid.h gattservapp_util.c
    ../../../../../../../../source/ti/ble5stack/profiles/serial_port/: serial_port_service.c serial_port_service.h
  group SDI
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/npi/src/: npi_rxbuf.c npi_tl.c npi_tl_uart.c
    ../../../../../../../../source/ti/ble5stack/sdi/src/: sdi_task.c
    ../../../../../../../../source/ti/ble5stack/sdi/src/inc/: sdi_task.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc26x2r1lp_stack_FlashROM_Library.a
  group Startup
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/target/: board.c
    ../../../src/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../../: ble_release.cfg
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/ble5stack/common/cc26xx/iar/: cc26xx_app_and_stack_agama.icf
  group Tools/defines
    defines/: cc26x2r1lp_app_FlashROM_Debug.opt cc26x2r1lp_app_FlashROM_Release.opt
