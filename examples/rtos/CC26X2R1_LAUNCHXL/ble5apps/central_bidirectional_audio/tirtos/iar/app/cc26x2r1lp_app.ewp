# IAR project cc26x2r1lp_app.ewp, settings and files
configuration FlashROM_Release (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC26X2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_LOCAL_DIR$/source/ti/ble5stack/; $SRC_LOCAL_DIR$/source/; $SRC_LOCAL_DIR$/source/third_party/sbc/; $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\ble_release.cfg
  ILINK.IlinkOutputFile: ble5_central_bidirectional_audio_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2642=1; FLASH_ONLY_BUILD=1; ENCRYPTION_ROM=1; PAGE_ALIGN=1
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack_agama.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x2_v1.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x2_v1.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_multiMode_cc26x2_v1.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\iar\m4f\grlib.a; $SRC_LOCAL_DIR$/source/third_party/sbc/bin/iar/cc26xx_mSBC_library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_Debug (ARM, debug)
  as the first configuration, except:
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\ble_debug.cfg
  group Application
    $SRC_BLE_DIR$/common/cc26xx/: board_key.c board_key.h util.c util.h
    $EXAMPLE_BLE_ROOT$/src/app/: central_bidirectional_audio.c central_bidirectional_audio.h
  group Application/menu
    ../../../src/app/: central_bidirectional_audio_menu.c central_bidirectional_audio_menu.h
    $SRC_BLE_DIR$/common/cc26xx/menu/: two_btn_menu.c two_btn_menu.h
    $SRC_LOCAL_DIR$/source/ti/audiocodec/: audiocodec_config_menu.c audiocodec_config_menu.h
  group Audio
    $SRC_LOCAL_DIR$/source/ti/ble5stack/profiles/audio_dle/: audio_client_disc.h audio_client_disc.c audio_profile_dle.h audio_profile_dle.c audio_duplex.h audio_duplex.c
  group Drivers/NV
    $SRC_BLE_DIR$/services/src/nv/cc26xx/: crc.c crc.h nvoctp.c nvoctp.h
  group Drivers/TRNG
    $SRC_BLE_DIR$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/Audio Codec
    $SRC_LOCAL_DIR$/source/ti/audiocodec/: audiocodec.h audiocodec.c ti3254.h
  group Drivers/I2S
    $SRC_LOCAL_DIR$/source/ti/drivers/i2s/: I2SCC26XX.h I2SCC26XX.c
  group Drivers/Codec 1
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/drivers/pdm/: Codec1.h Codec1.c
  group ICall
    $SRC_BLE_DIR$/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_BLE_DIR$/icall/src/inc/: icall.h
    $SRC_BLE_DIR$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/icall/app/: ble_user_config.c icall_api_lite.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    $SRC_BLE_DIR$/inc/: gap.h gapbondmgr.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_DIR$/osal/src/inc/: osal_snv.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc26x2r1lp_stack_FlashROM_Library.a
  group Startup
    $SRC_BLE_DIR$/target/: board.c
    $EXAMPLE_BLE_ROOT$/src/: ccfg_app_ble.c
    $EXAMPLE_BLE_ROOT$/src/app/: main.c
  group Startup/Board I2S
    $SRC_LOCAL_DIR$/source/ti/boards/CC26X2R1_LAUNCHXL_I2S/: Board_I2S.h CC26X2R1_LAUNCHXL_I2S.c CC26X2R1_LAUNCHXL_I2S.h
  group Tools
    ../../: ble_debug.cfg ble_release.cfg
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app_and_stack_agama.icf
  group Tools/defines
    defines/: cc26x2r1lp_app_FlashROM_Debug.opt cc26x2r1lp_app_FlashROM_Release.opt
