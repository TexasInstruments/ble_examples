<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/i2secho.ewp</path>
  </project>
  <project>
    <path>$SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC26X2R1_LAUNCHXL/release/iar/tirtos_builds_CC26X2R1_LAUNCHXL_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
