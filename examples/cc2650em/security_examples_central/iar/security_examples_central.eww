<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\cc2640em_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\stack\cc2640em_stack.ewp</path>
  </project>
  <batchBuild/>
</workspace>


