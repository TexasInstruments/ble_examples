# IAR project cc2650em_stack.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_ICALL; FLASH_ROM_BUILD; POWER_SAVING; INCLUDE_AES_DECRYPT; OSAL_SNV=1; xPM_DISABLE_PWRDOWN; xTESTMODES; xTEST_BLEBOARD; OSAL_CBTIMER_NUM_TASKS=1; DEBUG; HALNODEBUG; xDEBUG_GPIO; xDEBUG_ENC; xDEBUG_SW_TRACE; NEAR_FUNC=; DATA=; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi; -f $SRC_EX$/config/build_components.opt; -f build_config.opt
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_BLE_CORE$/rom; $SRC_EX$/common/cc26xx; $SRC_EX$/common/cc26xx/npi/stack; $SRC_COMMON$/hal/src/target/_common; $SRC_EX$/examples/simple_central/cc26xx/stack; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/roles; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/npi/src; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/aes/cc26xx; $SRC_COMMON$/services/src/nv; $SRC_COMMON$/services/src/nv/cc26xx; $SRC_COMMON$/services/src/saddr; $CC26XXWARE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: central_to_multiperipheral_cc2650em_stack.hex
  prebuild: "$TOOLS_BLE$/lib_search/lib_search.exe" build_config.opt "$TOOLS_BLE$/lib_search/params_split_cc2640.xml" $SRC_BLE_CORE$/../blelib  ../config/lib_linker.cmd
  postbuild: "$TOOLS_BLE$/frontier/frontier.exe" iar "$CONFIG_NAME$/List/central_to_multiperipheral_cc2650em_stack.map" "../config/iar_boundary.bdef" "../config/iar_boundary.xcl"
  ILINK.IlinkOutputFile: central_to_multiperipheral_cc2650em_stack.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=1; CC2650=1
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_stack.icf
  ILINK.IlinkExtraOptions: -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: $ROM$/ble_rom_releases/04242014/ble_rom_patch.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $SRC_BLE_CORE$/rom/enc_lib/cc26xx_ecc_rom_api.a
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/Common
    $SRC_COMMON$/hal/src/common/: hal_assert.c
  group HAL/Include
    $SRC_COMMON$/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $SRC_COMMON$/hal/src/target/cc2650tirtos/: hal_mcu.h
    $SRC_COMMON$/hal/src/target/_common/cc26xx/: mb.c mb.h mb_patch.c rf_hal.c rf_hal.h
  group HAL/Target/CC2650/Config
    $SRC_COMMON$/hal/src/target/cc2650tirtos/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $SRC_COMMON$/hal/src/target/_common/: hal_flash_wrapper.c hal_gpio_wrapper.h hal_rtc_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group ICallBLE
    $SRC_BLE_CORE$/icall/stack/: ble_dispatch.c
    $SRC_BLE_CORE$/icall/inc/: ble_dispatch.h
  group INCLUDE
    $SRC_BLE_CORE$/inc/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    $SRC_BLE_CORE$/host/: linkdb.h
    $SRC_BLE_CORE$/controller/cc26xx/inc/: ll.h
  group LIB
    ../config/: lib_linker.cmd
  group NPI
    $SRC_BLE_CORE$/common/cc26xx/npi/stack/: npi.c npi.h
  group OSAL
    $SRC_COMMON$/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    $SRC_COMMON$/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    $SRC_COMMON$/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group PROFILES
    $SRC_BLE_CORE$/profiles/roles/: gap.c gapbondmgr.c gapbondmgr.h
    $SRC_BLE_CORE$/host/: gattservapp_util.c
    $SRC_EX$/host/: sm_ecc.c
  group Startup
    $SRC_BLE_CORE$/icall/stack/: ble_user_config.c
    $SRC_BLE_CORE$/common/cc26xx/: icall_startup.c
    ../../../../../src/examples/central_to_multiperipheral/cc26xx/stack/: osal_icall_ble.c
    $ROM$/: rom_jt.c
  group TOOLS
    $SRC_BLE_CORE$/config/: build_components.opt
    ./: build_config.opt
    $SRC_BLE_CORE$/common/cc26xx/iar/: cc26xx_stack.icf
    $SRC_BLE_CORE$/common/cc26xx/: onboard.c onboard.h
