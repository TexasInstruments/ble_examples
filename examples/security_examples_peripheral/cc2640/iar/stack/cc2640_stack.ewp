# IAR project cc2640_stack.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; FLASH_ROM_BUILD; POWER_SAVING; GATT_NO_CLIENT; INCLUDE_AES_DECRYPT; xPM_DISABLE_PWRDOWN; xTESTMODES; xTEST_BLEBOARD; OSAL_CBTIMER_NUM_TASKS=1; xDEBUG; HALNODEBUG; xDEBUG_GPIO; xDEBUG_ENC; xDEBUG_SW_TRACE; NEAR_FUNC=; DATA=; CC26XXWARE; CC26XX
  ICCARM.IExtraOptions: --aeabi; -f $SRC_EX$/config/build_components.opt; -f build_config.opt
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../../src/security_examples_peripheral_peripheral_peripheral/cc26xx/stack; $SRC_EX$/inc; $SRC_EX$/common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650tirtos; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/nv/cc26xx; $SRC_COMMON$/services/src/nv; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/icall/src/inc; $SRC_BLE_CORE$/inc; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/rom; $SRC_BLE_CORE$/hci; $SRC_BLE_CORE$/host; $SRC_COMMON$/services/src/aes/cc26xx; $SRC_COMMON$/npi/src; $SRC_EX$/common/npi/npi_np/cc26xx/stack; $SRC_EX$/inc; $SRC_EX$/icall/inc; $SRC_EX$/profiles/roles; $SRC_BLE_CORE$/controller/cc26xx/cm0_patch; $CC26XXWARE$; $SRC_BLE_CORE$/rom/enc_lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: security_examples_peripheral_peripheral_peripheral_stack.hex
  prebuild: "$TOOLS$/lib_search/lib_search.exe" build_config.opt "$TOOLS$/lib_search/parameters.xml" $SRC_BLE_CORE$/../blelib  ..\..\lib\$PROJ_FNAME$.a flash_rom
  postbuild: "$BOUNDARY$/Boundary.exe" -chip "CC2640" -prj "iar" -lcf "$SRC_EX$/common/cc26xx/iar/cc26xx_stack.icf" -map "$CONFIG_NAME$/List/security_examples_peripheral_peripheral_peripheral_stack.map" -xml "$SRC_EX$/common/cc26xx/boundary/boundary_config.xml" -cc "../config/iar_boundary.bdef" -lnk "../config/iar_boundary.xcl" -log "../config/boundary.log"
  ILINK.IlinkOutputFile: security_examples_peripheral_peripheral_peripheral_stack.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=1; CC2650=1
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_stack.icf
  ILINK.IlinkExtraOptions: -f ../config/iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$/ble_rom_releases/04242014/ble_rom_patch.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $SRC_BLE_CORE$/rom/enc_lib/cc26xx_ecc_rom_api.a
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/Common
    $SRC_COMMON$/hal/src/common/: hal_assert.c
  group HAL/Include
    $SRC_COMMON$/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $SRC_COMMON$/hal/src/target/cc2650tirtos/: hal_mcu.h
    $SRC_COMMON$/hal/src/target/_common/cc26xx/: mb_patch.c
  group HAL/Target/CC2650/Config
    $SRC_COMMON$/hal/src/target/cc2650tirtos/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $SRC_COMMON$/hal/src/target/cc2650tirtos/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group ICallBLE
    $SRC_EX$/icall/stack/: ble_dispatch.c
    $SRC_EX$/icall/inc/: ble_dispatch.h
  group INCLUDE
    $SRC_BLE_CORE$/inc/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    $SRC_BLE_CORE$/host/: linkdb.h
    $SRC_BLE_CORE$/controller/cc26xx/inc/: ll.h
  group LIB
    ../../lib/: cc2640_stack.a cc2640_stack_hci_tl.a
  group NPI
    $SRC_EX$/common/npi/npi_np/cc26xx/stack/: npi.c
    $SRC_EX$/common/npi/npi_np/cc26xx/inc/: npi.h
  group OSAL
    $SRC_COMMON$/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    $SRC_COMMON$/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    $SRC_COMMON$/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group PROFILES
    $SRC_EX$/profiles/roles/: gap.c gapbondmgr.c gapbondmgr.h
    $SRC_BLE_CORE$/host/: gattservapp_util.c
  group Startup
    $SRC_EX$/icall/stack/: ble_user_config.c
    $SRC_BLE_CORE$/rom/: common_rom_init.c rom_init.c
    $SRC_EX$/common/cc26xx/: icall_startup.c
    ../../../../../src/security_examples_peripheral_peripheral_peripheral/cc26xx/stack/: osal_icall_ble.c
  group TOOLS
    $SRC_EX$/config/: build_components.opt
    ./: build_config.opt
    $SRC_EX$/common/cc26xx/iar/: cc26xx_stack.icf
    ../config/: iar_boundary.xcl
    $SRC_EX$/common/cc26xx/: onboard.c onboard.h
