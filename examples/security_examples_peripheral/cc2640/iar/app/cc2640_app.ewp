# IAR project cc2640_app.ewp, settings and files
configuration FlashROM-just_works (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../../src/security_examples_peripheral/cc26xx/app; $SRC_EX$/inc; $SRC_EX$/icall/inc; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/simple_profile/cc26xx; $SRC_EX$/profiles/simple_profile; $SRC_EX$/common/cc26xx; $SRC_COMMON$/applib/src/heap; $SRC_BLE_CORE$/hci; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/host; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/hal/src/target/cc2650tirtos; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/sdata; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/icall/src/inc; $SRC_BLE_CORE$/inc; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: security_examples_peripheral_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: security_examples_peripheral_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $SRC_EX$/common/cc26xx/: board_lcd.c board_lcd.h util.c util.h
    ../../../../../src/security_examples_peripheral/cc26xx/app/: just_works.c security_examples_peripheral.h
  group Board/Devices
    $SRC_EX$/sensortag/cc26xx/source/app/board_patch/devices/: ext_flash.c ext_flash.h
  group Board/Interfaces
    $SRC_EX$/sensortag/cc26xx/source/app/board_patch/interfaces/: bsp_spi.c bsp_spi.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $SRC_COMMON$/applib/src/heap/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $SRC_COMMON$/icall/src/inc/: icall.h
    $SRC_EX$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_EX$/icall/app/: ble_user_config.c icall_api.c
    $SRC_EX$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_CORE$/inc/: gap.h gatt.h hci.h
    $SRC_EX$/profiles/roles/: gapbondmgr.h
    $SRC_EX$/inc/: gapgattserver.h
    $SRC_COMMON$/osal/src/inc/: osal_snv.h
  group PROFILES
    $SRC_EX$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_EX$/profiles/dev_info/: devinfoservice.h
    $SRC_EX$/profiles/oad/cc26xx/: ext_flash_layout.h oad.c oad.h oad_reset_service.c oad_target_external_flash.c oad_target_internal_flash.c
    $SRC_EX$/inc/: gatt_profile_uuid.h
    $SRC_BLE_CORE$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_CORE$/inc/: gatt_uuid.h
    $SRC_EX$/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $SRC_EX$/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $SRC_EX$/profiles/simple_profile/: simple_gatt_profile.h
    $SRC_EX$/profiles/keys/cc26xx/: simplekeys.c
    $SRC_EX$/profiles/keys/: simplekeys.h
  group Startup
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SRF06EB/: Board.c
    $SRC_EX$/sensortag/cc26xx/source/app/board_patch/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../src/security_examples_peripheral/cc26xx/app/: main.c
  group TOOLS
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $SRC_EX$/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf
