# IAR project cc2640_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BROKEN; USE_ICALL; POWER_SAVING; MAX_NUM_BLE_CONNS=7; HEAPMGR_SIZE=0; TI_DRIVERS_DISPLAY_INCLUDED; BOARD_DISPLAY_EXCLUDE_UART; xBOARD_DISPLAY_EXCLUDE_LCD; GAPCENTRALROLE_NUM_RSSI_LINKS=1; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC2650DK_7ID; CC26XX; GAP_ROLE_ABORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/simple_profile; $SRC_EX$/profiles/simple_profile/cc26xx; $SRC_COMMON$/heapmgr; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: multi_role_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: multi_role_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $SRC_BLE_CORE$/common/cc26xx/: board_display.c board_display.h board_key.c board_key.h util.c util.h
    ../../../../../src/multi_role/cc26xx/app/: multi_role.c multi_role.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayDogm1286.c DisplayDogm1286.h DisplayUart.c DisplayUart.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/mw/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.c RF.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../../git/lprf-sd-common-components/applib/src/heap/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c
    ../../../../../../git/lprf-sd-common-components/icall/src/inc/: icall.h
    ../../../../../../git/ble_examples/src/icall/inc/: icall_addrs.h
    ../../../../../../git/lprf-sd-common-components/icall/src/: icall_platform.h
  group ICallBLE
    $SRC_BLE_CORE$/icall/app/: ble_user_config.c icall_api.c
    ../config/: ble_user_config.h
    ../../../../../../git/ble_examples/src/icall/inc/: icall_apimsg.h
  group Include
    ../../../../../../git/ble_core/src/inc/: gap.h gatt.h hci.h
    ../../../../../../git/ble_examples/src/profiles/roles/: gapbondmgr.h
    ../../../../../../git/ble_examples/src/inc/: gapgattserver.h
    ../../../../../../git/lprf-sd-common-components/osal/src/inc/: osal_snv.h
  group Profiles
    $SRC_BLE_CORE$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_BLE_CORE$/profiles/dev_info/: devinfoservice.h
    $SRC_BLE_CORE$/inc/: gatt_profile_uuid.h gatt_uuid.h
    $SRC_BLE_CORE$/host/: gatt_uuid.c gattservapp_util.c
    ../../../../../src/multi_role/cc26xx/app/: multi.c multi.h
    $SRC_BLE_CORE$/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $SRC_BLE_CORE$/profiles/simple_profile/: simple_gatt_profile.h
  group Startup
    $SRC_COMMON$/hal/src/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../src/multi_role/cc26xx/app/: main.c
  group TOOLS
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../../git/ble_examples/src/common/cc26xx/iar/: cc26xx_app.icf
