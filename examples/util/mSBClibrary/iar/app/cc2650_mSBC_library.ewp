# IAR project cc2650_mSBC_library.ewp, settings and files
configuration mSBCencode (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: xAUDIO_RECEIVER; AUDIO_TRANSMITTER; CC26XX; CC26XXWARE; TI_COMPILER_VERSION
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi
  ICCARM.CCIncludePath2: ../../../../../src/util/audio_codec; ../../../../../src/util/sbc; $SRC_BLE_CORE$/examples/simple_central/cc26xx/app; $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/simple_profile; $SRC_EX$/profiles/audio; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_central_audio_receiver_cc2650lp_app.hex
  ILINK.IlinkOutputFile: simple_central_audio_receiver_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $SRC_BLE_CORE$\rom\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mSBCdecode (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AUDIO_RECEIVER; xAUDIO_TRANSMITTER; CC26XX; CC26XXWARE; TI_COMPILER_VERSION
  group SBC
    ../../../../../src/util/sbc/: sbc.c sbc_primitives.c
