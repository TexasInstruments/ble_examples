# IAR project serial_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: PIN_UART_TXD=IOID_3; PIN_UART_RXD=IOID_2; PIN_SSP_MOSI=IOID_9; PIN_SSP_MISO=IOID_8; PIN_SSP_CSN=IOID_11; PIN_SSP_CLK=IOID_10; PIN_BL_ENTER=IOID_12; PIN_BL_ENTER_ACTIVE=0
  ICCARM.CCIncludePath2: ../../../../../src/util/serial_bootloader; $CC26XXWARE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: serial_bootloader.out
  ILINK.IlinkIcfFile: ../../../../../src/util/serial_bootloader/bl_flash.icf
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$/driverlib/bin/iar/driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../../../src/util/serial_bootloader/: autobaud.c bl_flash.icf blcmds.h boot_loader.c boot_loader.h main.c packet_handler.c ssp_handler.c uart_handler.c
    $CC26XXWARE$/startup_files/: ccfg.c startup_iar.c
