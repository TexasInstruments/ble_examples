<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$TI_BLE_SDK_BASE$\Projects\ble\util\BIM_extflash\CC26xx\IARBIM_extflash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Application\CC2640\CC2640App.ewp</path>
  </project>
  <batchBuild/>
</workspace>


