# IAR project CC2640App.ewp, settings and files
configuration cc2640em_sw_handshaking (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; POWER_SAVING; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_DEFAULT_USER_CFG; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; $TI_BLE_SDK_BASE$/Projects/ble/SAP/CC26xx/Source; $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile/SAP; $TI_BLE_SDK_BASE$/Projects/ble/Include; $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx; $TI_BLE_SDK_BASE$/Components/applib/heap; $TI_BLE_SDK_BASE$/Components/ble/hci; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650/rom; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK_BASE$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK_BASE$/Components/hal/include; $TI_BLE_SDK_BASE$/Components/osal/include; $TI_BLE_SDK_BASE$/Components/services/sdata; $TI_BLE_SDK_BASE$/Components/services/saddr; $TI_BLE_SDK_BASE$/Components/ble/include; ../../../../../../../Components/npi/unified; $TI_BLE_SDK_BASE$/Components/npi/unified; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application/Board_EM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_ap_em.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_ap.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3; ..\..\..\..\..\sap_lib_sw_handshaking\CC26xx\IAR\sap_lib_swhs\Exe\sap_lib_swhs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration cc2640em_sw_handshaking_debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
configuration cc2650stk_sw_handshaking (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; POWER_SAVING; FEATURE_OAD; HEAPMGR_SIZE=2672; TI_DRIVERS_PIN_INCLUDED; TI_DRIVERS_SPI_INCLUDED; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_DEFAULT_USER_CFG; CC26XXWARE; CC26XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; $TI_BLE_SDK_BASE$/Projects/ble/SAP/CC26xx/Source; $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/OAD/cc26xx; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/OAD/SAP; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile/SAP; $TI_BLE_SDK_BASE$/Projects/ble/Include; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/DevInfo; $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx; $TI_BLE_SDK_BASE$/Components/applib/heap; $TI_BLE_SDK_BASE$/Components/ble/hci; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650/rom; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK_BASE$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK_BASE$/Components/hal/include; $TI_BLE_SDK_BASE$/Components/osal/include; $TI_BLE_SDK_BASE$/Components/services/sdata; $TI_BLE_SDK_BASE$/Components/services/saddr; $TI_BLE_SDK_BASE$/Components/ble/include; ../../../../../../../Components/npi/unified; $TI_BLE_SDK_BASE$/Components/sbl/cc26xx; $TI_BLE_SDK_BASE$/Components/npi/unified; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/boards/sensortag/interfaces; $TI_RTOS_DRIVERS_BASE$/ti/boards/sensortag/devices; $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application/Board_STK
  OBJCOPY.OOCOutputFile: simple_ap_stk.hex
  ILINK.IlinkOutputFile: simple_ap_stk.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: $TI_BLE_SDK_BASE$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_app_oad.icf
configuration cc2650stk_sw_handshaking_debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: simple_ap_stk.hex
  ILINK.IlinkOutputFile: simple_ap_stk.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: as above
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  group Application
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/: board_key.c board_key.h board_lcd.c board_lcd.h util.c util.h
    ../../../Source/Application/: simple_ap_swhs.c simple_ap_swhs_stk.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application/: SimpleAP.h
  group Board/Devices
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SensorTag/Devices/: ext_flash.c ext_flash.h
  group Board/Interfaces
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SensorTag/Interfaces/: bsp_spi.c bsp_spi.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UART
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: UART.c UART.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/uart/: UARTCC26XX.c UARTCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group NPI
    ../../../../../../../Components/npi/unified/inc/: npi_data_swhs.h npi_task_swhs.h
    ../../../../../../../Components/npi/unified/: npi_task_swhs.c
    $TI_BLE_SDK_BASE$/Components/npi/unified/: npi_util.c
    $TI_BLE_SDK_BASE$/Components/npi/unified/inc/: npi_util.h
  group NPI/Subsystem
    $TI_BLE_SDK_BASE$/Projects/ble/SAP/CC26xx/Source/: npi_ss_ble_sap.c npi_ss_ble_sap.h
  group NPI/TL
    ../../../../../../../Components/npi/unified/: npi_tl_swhs.c
    ../../../../../../../Components/npi/unified/inc/: npi_tl_swhs.h
  group NPI/TL/UART
    ../../../../../../../Components/npi/unified/inc/: npi_tl_uart_swhs.h
    ../../../../../../../Components/npi/unified/: npi_tl_uart_swhs.c
  group PROFILES
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/OAD/SAP/: oad_sap.c oad_sap.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/OAD/CC26xx/: oad_target_externalFlash.c
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile/SAP/: simpleGATTprofile.c simpleGATTprofile.h
  group SAPSource
    $TI_BLE_SDK_BASE$/Projects/ble/SAP/CC26xx/Source/: sap.c sap.h snp_rpc.c snp_rpc.h snp_rpc_synchro.c snp_rpc_synchro.h
    $TI_BLE_SDK_BASE$/Projects/ble/Include/: SNP.h
  group SBL
    $TI_BLE_SDK_BASE$/Components/sbl/CC26xx/: sbl.c sbl.h sbl_cmd.c sbl_cmd.h sbl_image.h sbl_tl.c sbl_tl.h
    $TI_BLE_SDK_BASE$/Components/sbl/CC26xx/image/: sbl_image_ext.c
  group Startup
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application/Board_EM/: Board.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application/Board_STK/: Board.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/IAR/Config/: ccfg_appBLE.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleAP/CC26xx/Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/IAR/: cc26xx_ble_app.icf cc26xx_ble_app_oad.icf
