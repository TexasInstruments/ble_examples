# IAR project CC2640App.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $TI_BLE_SDK_BASE$\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; $TI_BLE_SDK_BASE$/Projects/ble/SimpleBLEPeripheral/CC26xx/Source/Application; $TI_BLE_SDK_BASE$/Projects/ble/Include; $TI_BLE_SDK_BASE$/Projects/ble/ICall/Include; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles/CC26xx; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/DevInfo; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile/CC26xx; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile; $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx; $TI_BLE_SDK_BASE$/Components/applib/heap; $TI_BLE_SDK_BASE$/Components/ble/hci; $TI_BLE_SDK_BASE$/Components/ble/controller/CC26xx/include; $TI_BLE_SDK_BASE$/Components/ble/host; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650/rom; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK_BASE$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK_BASE$/Components/hal/include; $TI_BLE_SDK_BASE$/Components/osal/include; $TI_BLE_SDK_BASE$/Components/services/sdata; $TI_BLE_SDK_BASE$/Components/services/saddr; $TI_BLE_SDK_BASE$/Components/icall/include; $TI_BLE_SDK_BASE$/Components/icall/ports/tirtos; $TI_BLE_SDK_BASE$/Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimpleBLEPeripheralAppFlashROM.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SimpleBLEPeripheralAppFlashROM.out
  ILINK.IlinkIcfFile: $TI_BLE_SDK_BASE$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/: board_lcd.c board_lcd.h util.c util.h
    ../../../../../common/cc26xx/: board_lcd_tirtos_2p15_port.c
    ../../../Source/Application/: simpleBLEPeripheral.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleBLEPeripheral/CC26xx/Source/Application/: simpleBLEPeripheral.h
  group Board
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SRF06EB/: Board.c
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $TI_BLE_SDK_BASE$/Components/applib/heap/: heapmgr.h
    $TI_BLE_SDK_BASE$/Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    $TI_BLE_SDK_BASE$/Components/icall/include/: ICall.h
    $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
    ../../../../../../../Components/icall/ports/tirtos/: ICallCC2650_tirtos_2p15_port.c
  group ICallBLE
    $TI_BLE_SDK_BASE$/Projects/ble/ICall/Application/: bleUserConfig.c ICallBleAPI.c
    $TI_BLE_SDK_BASE$/Projects/ble/ICall/Include/: bleUserConfig.h ICallBleAPIMSG.h
  group Include
    $TI_BLE_SDK_BASE$/Components/ble/include/: gap.h gatt.h hci.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles/: gapbondmgr.h
    $TI_BLE_SDK_BASE$/Projects/ble/Include/: gapgattserver.h
    $TI_BLE_SDK_BASE$/Components/osal/include/: osal_snv.h
  group PROFILES
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/DevInfo/CC26xx/: devinfoservice.c
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/DevInfo/: devinfoservice.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/OAD/CC26xx/: ext_flash_layout.h oad.c oad.h oad_target_externalFlash.c oad_target_internalFlash.c oadResetService.c
    $TI_BLE_SDK_BASE$/Projects/ble/Include/: gatt_profile_uuid.h
    $TI_BLE_SDK_BASE$/Components/ble/host/: gatt_uuid.c
    $TI_BLE_SDK_BASE$/Components/ble/include/: gatt_uuid.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/GATT/: gattservapp_util.c
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles/CC26xx/: peripheral.c peripheral.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile/CC26xx/: simpleGATTprofile.c
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile/: simpleGATTprofile.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Keys/CC26xx/: simplekeys.c
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Keys/: simplekeys.h
  group Startup
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg IAR-Boundary.bdef IAR-Boundary.xcl
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/IAR/: cc26xx_ble_app.icf cc26xx_ble_app_oad.icf
