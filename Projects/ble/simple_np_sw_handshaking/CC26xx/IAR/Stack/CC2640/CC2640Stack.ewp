# IAR project CC2640Stack.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; FLASH_ROM_BUILD; POWER_SAVING; GATT_NO_CLIENT; INCLUDE_AES_DECRYPT; xTESTMODES; OSAL_CBTIMER_NUM_TASKS=1; xDEBUG; HALNODEBUG; xDEBUG_GPIO; xDEBUG_ENC; xDEBUG_SW_TRACE; NEAR_FUNC=; DATA=; CC26XXWARE; CC26XX; OSAL_MAX_NUM_PROXY_TASKS=3; NO_OSAL_SNV; GATT_MAX_NUM_PREPARE_WRITES=24
  ICCARM.IExtraOptions: --aeabi; -f $TI_BLE_SDK_BASE$\Projects\ble\config\buildComponents.opt; -f buildConfig.opt; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Stack; ../../../include; ../../include; ../../include/CC2650; $TI_BLE_SDK_BASE$/Projects/ble/Include; $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK_BASE$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK_BASE$/Components/hal/include; $TI_BLE_SDK_BASE$/Components/osal/include; $TI_BLE_SDK_BASE$/Components/services/nv/cc26xx; $TI_BLE_SDK_BASE$/Components/services/nv; $TI_BLE_SDK_BASE$/Components/services/saddr; $TI_BLE_SDK_BASE$/Components/icall/include; $TI_BLE_SDK_BASE$/Components/ble/include; $TI_BLE_SDK_BASE$/Components/ble/controller/CC26xx/include; $TI_BLE_SDK_BASE$/Components/ble/ROM; $TI_BLE_SDK_BASE$/Components/ble/hci; $TI_BLE_SDK_BASE$/Components/ble/host; $TI_BLE_SDK_BASE$/Components/services/aes/CC26xx; $TI_BLE_SDK_BASE$/Components/npi; $TI_BLE_SDK_BASE$/Projects/ble/common/npi/npi_np/CC26xx/Stack; $TI_BLE_SDK_BASE$/Projects/ble/Include; $TI_BLE_SDK_BASE$/Projects/ble/ICall/Include; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles; $TI_BLE_SDK_BASE$/Projects/ble\Profiles\Roles\; $TI_BLE_SDK_BASE$/Components/ble/controller/CC26xx/CM0_Patch; $CC26XXWARE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SNPStackFlashROM.hex
  prebuild: $TI_BLE_SDK_BASE$\Projects\tools\LibSearch\libSearch.exe buildConfig.opt $TI_BLE_SDK_BASE$\Projects\tools\LibSearch\parameters.xml $TI_BLE_SDK_BASE$/Projects/ble\Libraries\CC26xx\IAR\ ..\..\Lib\$PROJ_FNAME$.a FlashROM
  postbuild: $BOUNDARY$\Boundary.exe -chip "CC2640" -prj "iar" -lcf "$TI_BLE_SDK_BASE$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_stack.icf" -map "$CONFIG_NAME$\List\simple_np_sw_handshaking_stack.map" -xml "$TI_BLE_SDK_BASE$\Projects\ble\common\cc26xx\Boundary\BoundaryConfig.xml" -cc "..\..\Config\IAR-Boundary.bdef" -lnk "..\..\Config\IAR-Boundary.xcl" -log "..\..\Config\Boundary.log"
  ILINK.IlinkOutputFile: simple_np_sw_handshaking_stack.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=1; CC2650=1
  ILINK.IlinkIcfFile: $TI_BLE_SDK_BASE$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_stack.icf
  ILINK.IlinkExtraOptions: -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $TI_BLE_SDK_BASE$\Projects\common\BLE_ROM_Releases\04242014\ble_rom_PATCH.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/Common
    $TI_BLE_SDK_BASE$/Components/hal/common/: hal_assert.c
  group HAL/Include
    $TI_BLE_SDK_BASE$/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS/: hal_mcu.h
    $TI_BLE_SDK_BASE$/Components/hal/target/_common/cc26xx/: mb_PATCH.c
  group HAL/Target/CC2650/Config
    $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group ICallBLE
    $TI_BLE_SDK_BASE$/Projects/ble/ICall/Stack/: bleDispatch.c
    $TI_BLE_SDK_BASE$/Projects/ble/ICall/Include/: bleDispatch.h
  group INCLUDE
    $TI_BLE_SDK_BASE$/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    $TI_BLE_SDK_BASE$/Components/ble/host/: linkdb.h
    $TI_BLE_SDK_BASE$/Components/ble/controller/CC26xx/include/: ll.h
  group LIB
    ../../Lib/: CC2640Stack.a CC2640Stack_HCI_TL.a
  group NPI
    $TI_BLE_SDK_BASE$/Projects/ble/common/npi/npi_np/CC26xx/Stack/: npi.c
    $TI_BLE_SDK_BASE$/Projects/ble/common/npi/npi_np/CC26xx/Include/: npi.h
    $TI_BLE_SDK_BASE$/Components/npi/inc/: npi_ble.h
  group OSAL
    $TI_BLE_SDK_BASE$/Components/osal/include/: comdef.h OSAL.h osal_bufmgr.h osal_cbtimer.h OSAL_Clock.h OSAL_Memory.h OSAL_PwrMgr.h osal_snv.h osal_task.h OSAL_Timers.h
    $TI_BLE_SDK_BASE$/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_Clock.c OSAL_MemoryICall.c OSAL_PwrMgr.c OSAL_Timers.c
    $TI_BLE_SDK_BASE$/Components/osal/mcu/cc26xx/: osal_snv_wrapper.c
  group PROFILES
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/GATT/: gattservapp_util.c
  group Startup
    $TI_BLE_SDK_BASE$/Projects/ble/ICall/Stack/: bleUserConfig.c
    $TI_BLE_SDK_BASE$/Components/ble/ROM/: CommonROM_Init.c ROM_Init.c
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/: ICall_startup.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleNP/CC26xx/Source/Stack/: OSAL_ICallBle.c
  group TOOLS
    $TI_BLE_SDK_BASE$/Projects/ble/config/: buildComponents.opt
    ./: buildConfig.opt
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/IAR/: cc26xx_ble_stack.icf
    ../../Config/: IAR-Boundary.bdef IAR-Boundary.xcl
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/: OnBoard.c OnBoard.h
