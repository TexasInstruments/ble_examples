# IAR project CC2640App.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; xSNP_SBL_ENABLE; POWER_SAVING; NPI_SW_HANDSHAKING_DEBUG; HEAPMGR_SIZE=9300; xTI_DRIVERS_LCD_INCLUDED; xTI_DRIVERS_SPI_DMA_INCLUDED; CC2650_HOSTTESTAPP; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; NPI_USE_UART; CC26XX; ICALL_MAX_NUM_ENTITIES=8; ICALL_MAX_NUM_TASKS=4; MAX_NUM_BLE_CONNS=1; xSWO_DEBUG; NO_OSAL_SNV; HEAPMGR_METRICS; MAX_PDU_SIZE=251; MAX_NUM_PDU=6
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $TI_BLE_SDK_BASE$\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Components/npi/unified/inc; ../../../../../../../Components/npi/unified; $TI_BLE_SDK_BASE$/Components/npi/unified/inc; $TI_BLE_SDK_BASE$/Components/npi/unified; $TI_BLE_SDK_BASE$/Projects/ble/include; $TI_BLE_SDK_BASE$/Projects/ble/ICall/Include; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles/CC26xx; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/DevInfo; $TI_BLE_SDK_BASE$/Projects/ble/Profiles/SimpleProfile; $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx; $TI_BLE_SDK_BASE$/Components/applib/heap; $TI_BLE_SDK_BASE$/Components/ble/hci; $TI_BLE_SDK_BASE$/Components/ble/controller/CC26xx/include; $TI_BLE_SDK_BASE$/Components/ble/host; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650/rom; $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK_BASE$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK_BASE$/Components/hal/include; $TI_BLE_SDK_BASE$/Components/osal/include; $TI_BLE_SDK_BASE$/Components/services/sdata; $TI_BLE_SDK_BASE$/Components/services/saddr; $TI_BLE_SDK_BASE$/Components/icall/include; $TI_BLE_SDK_BASE$/Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SNPAppFlashROM.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_np_sw_handshaking_flashrom.out
  ILINK.IlinkIcfFile: $TI_BLE_SDK_BASE$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleNP/CC26xx/Source/Application/: simpleNP.c simpleNP.h simpleNP_DEV.c simpleNP_DEV.h simpleNP_GAP.c simpleNP_GAP.h simpleNP_GATT.c simpleNP_GATT.h simpleNP_UUID.c simpleNP_UUID.h simpleNP_vendor_UUID.h
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/: util.c util.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UART
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: UART.c UART.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/uart/: UARTCC26XX.c UARTCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $TI_BLE_SDK_BASE$/Components/applib/heap/: heapmgr.h
    $TI_BLE_SDK_BASE$/Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    $TI_BLE_SDK_BASE$/Components/icall/include/: ICall.h
    $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    $TI_BLE_SDK_BASE$/Projects/ble/ICall/Application/: bleUserConfig.c ICallBleAPI.c
    $TI_BLE_SDK_BASE$/Projects/ble/ICall/Include/: bleUserConfig.h ICallBleAPIMSG.h
  group NPI/Transport
    ../../../../../../../Components/npi/unified/: npi_tl_swhs.c
    ../../../../../../../Components/npi/unified/inc/: npi_tl_swhs.h
  group NPI/Transport/SPI
    $TI_BLE_SDK_BASE$/Components/npi/unified/: npi_tl_spi.c
    $TI_BLE_SDK_BASE$/Components/npi/unified/inc/: npi_tl_spi.h
  group NPI/Transport/UART
    $TI_BLE_SDK_BASE$/Components/npi/unified/: npi_tl_uart.c
    ../../../../../../../Components/npi/unified/inc/: npi_tl_uart_swhs.h
    ../../../../../../../Components/npi/unified/: npi_tl_uart_swhs.c
  group NPI/U_NPI
    ../../../../../../../Components/npi/unified/inc/: npi_data_swhs.h
    ../../../../../../../Components/npi/unified/: npi_task_swhs.c
    $TI_BLE_SDK_BASE$/Components/npi/unified/inc/: npi_task.h npi_util.h
    $TI_BLE_SDK_BASE$/Components/npi/unified/: npi_util.c
  group PROFILES
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/DevInfo/CC26xx/: devinfoservice.c
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/DevInfo/: devinfoservice.h
    $TI_BLE_SDK_BASE$/Projects/ble/Include/: gatt_profile_uuid.h
    $TI_BLE_SDK_BASE$/Components/ble/host/: gatt_uuid.c
    $TI_BLE_SDK_BASE$/Components/ble/include/: gatt_uuid.h
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/GATT/: gattservapp_util.c
    $TI_BLE_SDK_BASE$/Projects/ble/Profiles/Roles/CC26xx/: peripheral.c peripheral.h
  group Startup
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SRF06EB/: Board.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleNP/CC26xx/IAR/Config/: ccfg_sbl.c
    $TI_BLE_SDK_BASE$/Projects/ble/SimpleNP/CC26xx/Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg IAR-Boundary.bdef IAR-Boundary.xcl
    $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx/IAR/: cc26xx_ble_app.icf
