# IAR project sap_lib_sw_handshaking.ewp, settings and files
configuration sap_lib_swhs (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; POWER_SAVING
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi; -Dxdc_target_name__=M3; -Dxdc_target_types__=iar/targets/arm/std.h
  ICCARM.CCIncludePath2: $TI_BLE_SDK_BASE$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK_BASE$/Components/hal/include; $TI_BLE_SDK_BASE$/Components/osal/include; $TI_BLE_SDK_BASE$/Components/ble/include; ../../../../../Components/npi/unified; $TI_BLE_SDK_BASE$/Components/npi/unified; $TI_BLE_SDK_BASE$/Components/npi/unified/subsystem; $TI_BLE_SDK_BASE$/Projects/ble/Include; $TI_BLE_SDK_BASE$/Projects/ble/common/cc26xx; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID; $XDCPATH$; $XDCROOT$/packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ApplicationProcessor.hex
  ILINK.IlinkOutputFile: ApplicationProcessor.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkIcfFile: $TI_BLE_SDK_BASE$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group NPI
    ../../../../../Components/npi/unified/inc/: npi_data_swhs.h npi_task_swhs.h
    ../../../../../Components/npi/unified/: npi_task_swhs.c
    $TI_BLE_SDK_BASE$/Components/npi/unified/: npi_util.c
    $TI_BLE_SDK_BASE$/Components/npi/unified/inc/: npi_util.h
  group NPI/Subsystem
    $TI_BLE_SDK_BASE$/Projects/ble/SAP/CC26xx/Source/: npi_ss_ble_sap.c npi_ss_ble_sap.h
  group NPI/TL
    ../../../../../Components/npi/unified/: npi_tl_swhs.c
    ../../../../../Components/npi/unified/inc/: npi_tl_swhs.h
  group NPI/TL/UART
    ../../../../../Components/npi/unified/: npi_tl_uart_swhs.c
    ../../../../../Components/npi/unified/inc/: npi_tl_uart_swhs.h
  group SAP
    $TI_BLE_SDK_BASE$/Projects/ble/SAP/CC26xx/Source/: sap.c sap.h snp_rpc.c snp_rpc.h snp_rpc_synchro.c snp_rpc_synchro.h
    $TI_BLE_SDK_BASE$/Projects/ble/Include/: SNP.h
