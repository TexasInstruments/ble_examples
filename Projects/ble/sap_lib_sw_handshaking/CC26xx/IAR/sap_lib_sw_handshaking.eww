<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sap_lib_sw_handshaking.ewp</path>
  </project>
  <batchBuild/>
</workspace>


